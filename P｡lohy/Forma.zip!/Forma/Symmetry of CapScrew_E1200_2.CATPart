# CATIA V5 part "Symmetry of CapScrew_E1200_2.CATPart"
Saved by CATIA V5R30
Part number: Sroub_M6x36_1
Stored file links:
  E:\Bakalarka\Model\Forma_v7\Symmetry of CapScrew_E1200_2.CATPart
  E:\Bakalarka\Model\Forma_v7\CapScrew_E1200_2.CATPart

## Design history (mm, degrees; sets first, then bodies; in a sketch O, H, V are its origin and axes)
Body1 (main body)